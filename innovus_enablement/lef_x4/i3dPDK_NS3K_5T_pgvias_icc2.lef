# PG vias with the geometry of the ICC2 flow's PDN vias (its DEF VIAS section: cut 10 x 10 nm, cut spacing
# 10 nm, one row of n cuts, the enclosures below), 4x like i3dPDK_NS3K_5T_tech*.lef. For PG_VIA_LEF /
# PG_VIA_PREF (pnr/flow.tcl): Innovus' editPowerVia -via_using_exact_crossover_size otherwise generates the
# stripe/pillar crossing vias from the VIA*_gen rules with the M1/M2 pads stretched to the crossover
# (VIA12: M2 pad 48 x 16 nm vs ICC2 32 x 12 nm).
VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 2000 ;
END UNITS

VIA PGVIA01_1_2
  LAYER M0 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER M1 ;
    RECT -0.0720 -0.0320 0.0720 0.0320 ;
  LAYER VIA0 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
END PGVIA01_1_2

VIA PGVIA01_1_5
  LAYER M0 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER M1 ;
    RECT -0.1920 -0.0320 0.1920 0.0320 ;
  LAYER VIA0 ;
    RECT -0.1800 -0.0200 -0.1400 0.0200 ;
    RECT -0.1000 -0.0200 -0.0600 0.0200 ;
    RECT -0.0200 -0.0200 0.0200 0.0200 ;
    RECT 0.0600 -0.0200 0.1000 0.0200 ;
    RECT 0.1400 -0.0200 0.1800 0.0200 ;
END PGVIA01_1_5

VIA PGVIA12_1_2
  LAYER M1 ;
    RECT -0.0720 -0.0320 0.0720 0.0320 ;
  LAYER M2 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER VIA1 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
END PGVIA12_1_2

VIA PGVIA12_1_5
  LAYER M1 ;
    RECT -0.1920 -0.0320 0.1920 0.0320 ;
  LAYER M2 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER VIA1 ;
    RECT -0.1800 -0.0200 -0.1400 0.0200 ;
    RECT -0.1000 -0.0200 -0.0600 0.0200 ;
    RECT -0.0200 -0.0200 0.0200 0.0200 ;
    RECT 0.0600 -0.0200 0.1000 0.0200 ;
    RECT 0.1400 -0.0200 0.1800 0.0200 ;
END PGVIA12_1_5

VIA PGVIA23_1_2
  LAYER M2 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER M3 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER VIA2 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
END PGVIA23_1_2

VIA PGVIA23_1_5
  LAYER M2 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER M3 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER VIA2 ;
    RECT -0.1800 -0.0200 -0.1400 0.0200 ;
    RECT -0.1000 -0.0200 -0.0600 0.0200 ;
    RECT -0.0200 -0.0200 0.0200 0.0200 ;
    RECT 0.0600 -0.0200 0.1000 0.0200 ;
    RECT 0.1400 -0.0200 0.1800 0.0200 ;
END PGVIA23_1_5

VIA PGVIA34_1_2
  LAYER M3 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER M4 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER VIA3 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
END PGVIA34_1_2

VIA PGVIA34_1_5
  LAYER M3 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER M4 ;
    RECT -0.1840 -0.0240 0.1840 0.0240 ;
  LAYER VIA3 ;
    RECT -0.1800 -0.0200 -0.1400 0.0200 ;
    RECT -0.1000 -0.0200 -0.0600 0.0200 ;
    RECT -0.0200 -0.0200 0.0200 0.0200 ;
    RECT 0.0600 -0.0200 0.1000 0.0200 ;
    RECT 0.1400 -0.0200 0.1800 0.0200 ;
END PGVIA34_1_5

VIA PGVIA45_1_2
  LAYER M4 ;
    RECT -0.0640 -0.0240 0.0640 0.0240 ;
  LAYER M5 ;
    RECT -0.0840 -0.0440 0.0840 0.0440 ;
  LAYER VIA4 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
END PGVIA45_1_2

VIA PGVIA45_1_4
  LAYER M4 ;
    RECT -0.1440 -0.0240 0.1440 0.0240 ;
  LAYER M5 ;
    RECT -0.1640 -0.0440 0.1640 0.0440 ;
  LAYER VIA4 ;
    RECT -0.1400 -0.0200 -0.1000 0.0200 ;
    RECT -0.0600 -0.0200 -0.0200 0.0200 ;
    RECT 0.0200 -0.0200 0.0600 0.0200 ;
    RECT 0.1000 -0.0200 0.1400 0.0200 ;
END PGVIA45_1_4

END LIBRARY
